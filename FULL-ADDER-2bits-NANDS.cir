********************************************************************************
* SPICE netlist generated by HiPer Verify's NetList Extractor
*
* Extract Date/Time:	Mon Jul 30 21:11:51 2018
* L-Edit Version:		L-Edit Win64 16.01.20130408.01:22:50
*
* Rule Set Name:
* TDB File Name:		C:\Users\patri\Desktop\versao_final_t2-cci\FA_NANDS.tdb
* Command File:		C:\Users\patri\Desktop\versao_final_t2-cci\ams035.ext
* Cell Name:			FULL-ADDER-NANDS
* Write Flat:			NO
********************************************************************************

.include ami_035u.mod

vcc vcc 0 dc 3.3v
Vgnd GND_ 0 dc 0V

Va0 	A0 0 pulse(0 3.3 0 0.1nS 0.1ns 1ns 2.2ns)
Vb0 	B0 0 pulse(0 3.3 0 0.1nS 0.1ns 2ns 4.4ns)
Va1 	A1 0 pulse(0 3.3 0 0.1nS 0.1ns 4ns 8.8ns)
Vb1 	B1 0 pulse(0 3.3 0 0.1nS 0.1ns 8ns 16.16ns)

*C0 no diagrama
Vcin 	CIN 0 dc 0v

****************************************

M1 1 A0 out_2 2 CMOSN l=3e-007 w=2.55e-006  $ (-5.6 -7.75 -5.3 -5.2)
M2 GND_ out_1 1 2 CMOSN l=3e-007 w=2.55e-006  $ (-4.7 -7.75 -4.4 -5.2)
M3 3 A0 out_1 2 CMOSN l=3e-007 w=2.55e-006  $ (0.15 -7.7 0.45 -5.15)
M4 GND_ B0 3 2 CMOSN l=3e-007 w=2.55e-006  $ (1.35 -7.7 1.65 -5.15)
M5 4 out_1 GND_ 2 CMOSN l=3e-007 w=2.55e-006  $ (3.75 -7.7 4.05 -5.15)
M6 out_3 B0 4 2 CMOSN l=3e-007 w=2.55e-006  $ (4.95 -7.7 5.25 -5.15)
M7 5 out_2 GND_ 2 CMOSN l=3e-007 w=2.6e-006  $ (10 -7.75 10.3 -5.15)
M8 out_4 out_3 5 2 CMOSN l=3e-007 w=2.6e-006  $ (11.2 -7.75 11.5 -5.15)
M9 6 out_4 OUT6 2 CMOSN l=3e-007 w=1.5e-006  $ (16.9 -7.65 17.2 -6.15)
M10 GND_ OUT5 6 2 CMOSN l=3e-007 w=1.5e-006  $ (18 -7.65 18.3 -6.15)
M11 7 out_4 OUT5 2 CMOSN l=3e-007 w=2.55e-006  $ (22.15 -7.7 22.45 -5.15)
M12 GND_ CIN 7 2 CMOSN l=3e-007 w=2.55e-006  $ (23.35 -7.7 23.65 -5.15)
M13 8 OUT5 GND_ 2 CMOSN l=3e-007 w=2.55e-006  $ (25.75 -7.7 26.05 -5.15)
M14 OUT7 CIN 8 2 CMOSN l=3e-007 w=2.55e-006  $ (26.95 -7.7 27.25 -5.15)
M15 9 OUT6 GND_ 2 CMOSN l=3e-007 w=2.6e-006  $ (32 -7.75 32.3 -5.15)
M16 S0 OUT7 9 2 CMOSN l=3e-007 w=2.6e-006  $ (33.2 -7.75 33.5 -5.15)
M17 10 OUT5 cout1 2 CMOSN l=3e-007 w=3e-006  $ (38.25 -8.15 38.55 -5.15)
M18 GND_ out_1 10 2 CMOSN l=3e-007 w=3e-006  $ (39.45 -8.15 39.75 -5.15)
M19 11 A1 out_9 2 CMOSN l=3e-007 w=2.55e-006  $ (45.25 -7.75 45.55 -5.2)
M20 GND_ out_8 11 2 CMOSN l=3e-007 w=2.55e-006  $ (46.15 -7.75 46.45 -5.2)
M21 12 A1 out_8 2 CMOSN l=3e-007 w=2.55e-006  $ (51 -7.7 51.3 -5.15)
M22 GND_ B1 12 2 CMOSN l=3e-007 w=2.55e-006  $ (52.2 -7.7 52.5 -5.15)
M23 13 out_8 GND_ 2 CMOSN l=3e-007 w=2.55e-006  $ (54.6 -7.7 54.9 -5.15)
M24 out_10 B1 13 2 CMOSN l=3e-007 w=2.55e-006  $ (55.8 -7.7 56.1 -5.15)
M25 14 out_9 GND_ 2 CMOSN l=3e-007 w=2.6e-006  $ (60.85 -7.75 61.15 -5.15)
M26 out_11 out_10 14 2 CMOSN l=3e-007 w=2.6e-006  $ (62.05 -7.75 62.35 -5.15)
M27 15 out_11 OUT13 2 CMOSN l=3e-007 w=1.5e-006  $ (67.75 -7.65 68.05 -6.15)
M28 GND_ OUT12 15 2 CMOSN l=3e-007 w=1.5e-006  $ (68.85 -7.65 69.15 -6.15)
M29 16 out_11 OUT12 2 CMOSN l=3e-007 w=2.55e-006  $ (73 -7.7 73.3 -5.15)
M30 GND_ cout1 16 2 CMOSN l=3e-007 w=2.55e-006  $ (74.2 -7.7 74.5 -5.15)
M31 17 OUT12 GND_ 2 CMOSN l=3e-007 w=2.55e-006  $ (76.6 -7.7 76.9 -5.15)
M32 OUT14 cout1 17 2 CMOSN l=3e-007 w=2.55e-006  $ (77.8 -7.7 78.1 -5.15)
M33 18 OUT13 GND_ 2 CMOSN l=3e-007 w=2.6e-006  $ (82.85 -7.75 83.15 -5.15)
M34 S1 OUT14 18 2 CMOSN l=3e-007 w=2.6e-006  $ (84.05 -7.75 84.35 -5.15)
M35 19 OUT12 cout2 2 CMOSN l=3e-007 w=3e-006  $ (89.1 -8.15 89.4 -5.15)
M36 GND_ out_8 19 2 CMOSN l=3e-007 w=3e-006  $ (90.3 -8.15 90.6 -5.15)
M37 out_2 A0 VCC 20 CMOSP l=3e-007 w=4.3e-006  $ (-3.65 -1.4 -3.35 2.9)
M38 VCC out_1 out_2 20 CMOSP l=3e-007 w=4.3e-006  $ (-2.45 -1.4 -2.15 2.9)
M39 out_1 A0 VCC 20 CMOSP l=3e-007 w=4.3e-006  $ (0.15 -1.4 0.45 2.9)
M40 VCC B0 out_1 20 CMOSP l=3e-007 w=4.3e-006  $ (1.35 -1.4 1.65 2.9)
M41 out_3 out_1 VCC 20 CMOSP l=3e-007 w=4.3e-006  $ (3.75 -1.4 4.05 2.9)
M42 VCC B0 out_3 20 CMOSP l=3e-007 w=4.3e-006  $ (4.95 -1.4 5.25 2.9)
M43 out_4 out_2 VCC 20 CMOSP l=3.07143e-007 w=4.2e-006  $ (10 -1.5 10.3 2.8)
M44 VCC out_3 out_4 20 CMOSP l=3.07143e-007 w=4.2e-006  $ (11.2 -1.5 11.5 2.8)
M45 OUT6 out_4 VCC 21 CMOSP l=3e-007 w=4.3e-006  $ (18.35 -1.4 18.65 2.9)
M46 VCC OUT5 OUT6 21 CMOSP l=3e-007 w=4.3e-006  $ (19.55 -1.4 19.85 2.9)
M47 OUT5 out_4 VCC 21 CMOSP l=3e-007 w=4.3e-006  $ (22.15 -1.4 22.45 2.9)
M48 VCC CIN OUT5 21 CMOSP l=3e-007 w=4.3e-006  $ (23.35 -1.4 23.65 2.9)
M49 OUT7 OUT5 VCC 21 CMOSP l=3e-007 w=4.3e-006  $ (25.75 -1.4 26.05 2.9)
M50 VCC CIN OUT7 21 CMOSP l=3e-007 w=4.3e-006  $ (26.95 -1.4 27.25 2.9)
M51 S0 OUT6 VCC 21 CMOSP l=3.07143e-007 w=4.2e-006  $ (32 -1.5 32.3 2.8)
M52 VCC OUT7 S0 21 CMOSP l=3.07143e-007 w=4.2e-006  $ (33.2 -1.5 33.5 2.8)
M53 cout1 OUT5 VCC 21 CMOSP l=3.07143e-007 w=4.2e-006  $ (38.25 -1.45 38.55 2.85)
M54 VCC out_1 cout1 21 CMOSP l=3.07143e-007 w=4.2e-006  $ (39.45 -1.45 39.75 2.85)
M55 out_9 A1 VCC 22 CMOSP l=3e-007 w=4.3e-006  $ (47.2 -1.4 47.5 2.9)
M56 VCC out_8 out_9 22 CMOSP l=3e-007 w=4.3e-006  $ (48.4 -1.4 48.7 2.9)
M57 out_8 A1 VCC 22 CMOSP l=3e-007 w=4.3e-006  $ (51 -1.4 51.3 2.9)
M58 VCC B1 out_8 22 CMOSP l=3e-007 w=4.3e-006  $ (52.2 -1.4 52.5 2.9)
M59 out_10 out_8 VCC 22 CMOSP l=3e-007 w=4.3e-006  $ (54.6 -1.4 54.9 2.9)
M60 VCC B1 out_10 22 CMOSP l=3e-007 w=4.3e-006  $ (55.8 -1.4 56.1 2.9)
M61 out_11 out_9 VCC 22 CMOSP l=3.07143e-007 w=4.2e-006  $ (60.85 -1.5 61.15 2.8)
M62 VCC out_10 out_11 22 CMOSP l=3.07143e-007 w=4.2e-006  $ (62.05 -1.5 62.35 2.8)
M63 OUT13 out_11 VCC 23 CMOSP l=3e-007 w=4.3e-006  $ (69.2 -1.4 69.5 2.9)
M64 VCC OUT12 OUT13 23 CMOSP l=3e-007 w=4.3e-006  $ (70.4 -1.4 70.7 2.9)
M65 OUT12 out_11 VCC 23 CMOSP l=3e-007 w=4.3e-006  $ (73 -1.4 73.3 2.9)
M66 VCC cout1 OUT12 23 CMOSP l=3e-007 w=4.3e-006  $ (74.2 -1.4 74.5 2.9)
M67 OUT14 OUT12 VCC 23 CMOSP l=3e-007 w=4.3e-006  $ (76.6 -1.4 76.9 2.9)
M68 VCC cout1 OUT14 23 CMOSP l=3e-007 w=4.3e-006  $ (77.8 -1.4 78.1 2.9)
M69 S1 OUT13 VCC 23 CMOSP l=3.07143e-007 w=4.2e-006  $ (82.85 -1.5 83.15 2.8)
M70 VCC OUT14 S1 23 CMOSP l=3.07143e-007 w=4.2e-006  $ (84.05 -1.5 84.35 2.8)
M71 cout2 OUT12 VCC 23 CMOSP l=3.07143e-007 w=4.2e-006  $ (89.1 -1.45 89.4 2.85)
M72 VCC out_8 cout2 23 CMOSP l=3.07143e-007 w=4.2e-006  $ (90.3 -1.45 90.6 2.85)
* Top level device count
* M(CMOSN)		36
* M(CMOSP)		36
* Number of devices:	72
* Number of nodes:	48

** ondas -------------------------------------------------------------------------------------------
.tran 1ns 8n
.probe

*saidas e i=input
.print v(cout1) v(cout2) v(a0) v(b0) v(a1) v(b1) v(S0) v(S1)
.end
