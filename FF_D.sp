* This description was generated by JELIS
.include ams35ps.lib

V0 gnd 0 DC 0V
V1 vcc 0 DC 3.3V

* The primary input is: A and CLK

Vin1 CLK gnd pulse (0 3.3 5n 100p 100p 20n 50n)
Vin2 A 0 DC 5v
.SUBCKT FFD CLK D out VCC GND
*.PININFO CLK:I D:I out:O VCC:P GND:G
*.EQN out=(D + !CLK);
MP1 out not_D VCC VCC PMOS
MP2 out CLK VCC VCC PMOS
MN3 pd_n1 not_D GND GND NMOS
MN4 out CLK pd_n1 GND NMOS
MP_inv5 not_D D VCC VCC PMOS
MN_inv6 not_D D GND GND NMOS
.ENDS FFD

.SUBCKT Nand A B out VCC GND
*.PININFO A:I B:I out:O VCC:P GND:G
*.EQN out=(!A + !B);
MP1 out A VCC VCC PMOS
MP2 out B VCC VCC PMOS
MN3 pd_n1 A GND GND NMOS
MN4 out B pd_n1 GND NMOS
.ENDS Nand

X1 Clk inD A VCC GND FFD
X2 Clk inD B VCC GND Nand
X3 A   Q_N Q VCC GND Nand
X4 B   Q   Q_N VCC GND Nand

* The output signal is: Q and Q_N

.tran 0.0002ns 50ns

.probe

.end
